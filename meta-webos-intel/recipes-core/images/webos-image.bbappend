# Copyright (c) 2019-2024 LG Electronics, Inc.

WEBOS_IMAGE_EXTRA_INSTALL:append = " glmark2 libdrm-tests strace kmscube "

