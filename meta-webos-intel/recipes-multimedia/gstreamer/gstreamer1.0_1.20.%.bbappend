# Copyright (c) 2018-2024 LG Electronics, Inc.
SRC_URI:append:intel-corei7-64 = " file://0001-Add-support-for-seamless-seek-trickplay.patch"

