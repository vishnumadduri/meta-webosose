#WEBOS_TARGET_MACHINE_IMPL = "hardware"
EXTRA_QMAKEVARS_PRE += "CURSOR_BACKEND=opengl"

