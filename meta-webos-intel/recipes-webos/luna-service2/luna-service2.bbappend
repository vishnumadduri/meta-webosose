EXTRA_OECMAKE += "-DWEBOS_GTEST_SRCDIR=${WORKDIR}/recipe-sysroot/usr/src/gtest"
