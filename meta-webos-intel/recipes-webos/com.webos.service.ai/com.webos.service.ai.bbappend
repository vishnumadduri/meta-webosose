COMPATIBLE_MACHINE = "rpi|aarch64|x86-64|qemux86-64|intel-corei7-64"
